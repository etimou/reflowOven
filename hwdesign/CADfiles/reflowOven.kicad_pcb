# Repository etimou/reflowOven

File README.md:

reflowOven
==========

A simple arduino based reflow oven

## KiCad design hwdesign/CADfiles/reflowOven.kicad_pcb

Parts:
C1, C2: 10u
C3: 0.1u
C4: 10n
C5: 100n
C6, C7: 22p
D1, D2: LED
IC1: ATMEGA328-P; DIL28
P1: CONN_6
P2: CONN_3
P3, P4: CONN_2
P5: CONN_3X2
R1: 10k
R2, R3: 1k
SW1, SW2: SW_PUSH_4PTS
U1: REGUL
U2: MAX31855
X1: 16MHz

Connections:
/3V3: C2.2, C3.1, IC1.7 (VCC), IC1.20 (AVCC), IC1.21 (AREF), R1.1, U1.2 (OUT), U2.4 (Vcc)
/5V: C1.2, P2.1, P3.2 (PM), U1.3 (IN)
/5V_USB: P1.3, P3.1
/CLK: IC1.6 ((PCINT20/XCK/T0)PD4), U2.5 (SCK)
/CS: IC1.5 ((PCINT19/OC2B/INT1)PD3), U2.6 (CS/)
/DTR: C5.1, P1.6
/RX: IC1.2 ((PCINT16/RXD)PD0), P1.4
/SO: IC1.4 ((PCINT18/INT0)PD2), U2.7 (SO)
/TX: IC1.3 ((PCINT17/TXD)PD1), P1.5
DNC: U2.8 (DNC)
GND: C1.1, C2.1, C3.2, C6.2, C7.2, D1.2 (K), D2.2 (K), IC1.8 (GND), IC1.22 (GND), P1.1, P2.2 (PM), P2.3, P5.2, P5.4, P5.6, SW1.3, SW1.4, SW2.3, SW2.4, U1.1 (ADJ), U2.1 (GND)
unnamed: C4.1, P4.2 (PM), U2.3 (T+)
unnamed: C4.2, P4.1, U2.2 (T-)
unnamed: IC1.15 ((PCINT1/OC1A)PB1), P5.1
unnamed: IC1.16 ((PCINT2/OC1B/~SS~)PB2), P5.3
unnamed: IC1.17 ((PCINT3/OC2A/MOSI)PB3), P5.5
unnamed: IC1.18 ((PCINT4/MISO)PB4), R2.1
unnamed: D1.1 (A), R2.2
unnamed: IC1.19 ((PCINT5/SCK)PB5), R3.1
unnamed: D2.1 (A), R3.2
unnamed: C5.2, IC1.1 ((PCINT14/~RESET~)PC6), R1.2
unnamed: C6.1, IC1.9 ((PCINT6/XTAL1/TOSC1)PB6), X1.2
unnamed: C7.1, IC1.10 ((PCINT7/XTAL2/TOSC2)PB7), X1.1
unnamed: IC1.27 ((PCINT12/SDA/ADC4)PC4), SW1.1, SW1.2
unnamed: IC1.28 ((PCINT14/SCL/ADC5)PC5), SW2.1, SW2.2

Notes on the sheet:
USB-Serial
POWER SUPPLY

Board: 2 copper layers, 85.0 x 45.0 mm, 31 parts (0 on the bottom side), 24 nets.

Other parts of the board:
Ref**: Val**; A_1pin
Ref**#2, Ref**#3, Ref**#4, Ref**#5, Ref**#6, Ref**#7, Ref**#8: Val**; A_1pin

## Commit log

2013-11-12 add ino file
2013-12-08 avancement
2014-05-30 add hw design
